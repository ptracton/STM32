# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 wLevel=2
  c define: STM32F303xC
  c include: ..\includes;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\CMSIS\Include;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\BSP\STM32F3-Discovery;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\BSP\Components\l3gd20;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\BSP\Components\lsm303dlhc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source
    ../src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group BSP
    ../../../../STM32Cube_FW_F3_V1.2.0/Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c stm32f3_discovery_accelerometer.c stm32f3_discovery_gyroscope.c
    ../../../../STM32Cube_FW_F3_V1.2.0/Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
    ../../../../STM32Cube_FW_F3_V1.2.0/Drivers/BSP/Components/l3gd20/: l3gd20.c
  group Drivers
    ../../../../STM32Cube_FW_F3_V1.2.0/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_ppp.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_fmc.c
  group ::Device
    RTE/Device/STM32F303VC/: startup_stm32f30x.s system_stm32f30x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
