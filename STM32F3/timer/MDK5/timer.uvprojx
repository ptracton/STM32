# Keil uVision project timer.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer
  c flags: Optim=1 wLevel=2
  c define: STM32F303xC, USE_HAL_DRIVER
  c include: ..\includes;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\CMSIS\Include;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\BSP\STM32F3-Discovery;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\BSP\Components\l3gd20;..\..\..\..\STM32Cube_FW_F3_V1.2.0\Drivers\BSP\Components\lsm303dlhc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source
    ../src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c system_stm32f3xx.c
    ./: startup_stm32f30x.s bsp_leds.c
  group Drivers
    ../../../../STM32Cube_FW_F3_V1.2.0/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
